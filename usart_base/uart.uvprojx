# Keil uVision project uart.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\..\【STM32代码】@梁攻克;.\CMSIS;.\Startup;.\USR;.\FWlib\INC;.\FreeModbus\include;.\PortModbus;.\FreeModbus\rtu;.\FreeModbus\ascii
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./Startup/: startup_stm32f10x_hd_vl.s
  group FWlib
    ./FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_it.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c core_cm3.h stm32f10x.h system_stm32f10x.h
  group USR
    ./USR/: main.c stm32f10x.h systick_usr.c input_usr.c output_usr.c usart_usr.c fifo.c util.c
  group FreeModbus
    ./FreeModbus/: mb.c
    ./FreeModbus/rtu/: mbcrc.c mbrtu.c
    ./FreeModbus/functions/: mbfuncholding.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncinput.c mbfuncother.c mbutils.c
    ./FreeModbus/ascii/: mbascii.c
    ./FreeModbus/tcp/: mbtcp.c
  group PortModbus
    ./PortModbus/: portevent.c portserial.c porttimer.c mbmap.c
